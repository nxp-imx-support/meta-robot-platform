PACKAGECONFIG_SOC:remove = "tvm"
