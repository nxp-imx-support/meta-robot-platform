EXTRA_OECMAKE += " -DLAPACKE=ON "