FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Add-supporting-public-key-cryptography-operations-an.patch \
"
