do_install:append () {
    rm -f ${D}${bindir}/nosetests
}
