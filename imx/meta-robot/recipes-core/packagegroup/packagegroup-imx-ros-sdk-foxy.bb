# Copyright 2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)
DESCRIPTION = "ros sdk package group for i.MX Robot platform"
LICENSE = "MIT"

inherit packagegroup
inherit ros_distro_${ROS_DISTRO}

PACKAGES = "${PN}"

RDEPENDS:${PN} = "\
    action-tutorials-cpp \
    action-tutorials-interfaces \
    action-tutorials-py \
    angles \
    composition \
    demo-nodes-cpp \
    demo-nodes-cpp-rosnative \
    demo-nodes-py \
    depthimage-to-laserscan \
    dummy-map-server \
    dummy-robot-bringup \
    dummy-sensors \
    examples-rclcpp-minimal-action-client \
    examples-rclcpp-minimal-action-server \
    examples-rclcpp-minimal-client \
    examples-rclcpp-minimal-composition \
    examples-rclcpp-minimal-publisher \
    examples-rclcpp-minimal-service \
    examples-rclcpp-minimal-subscriber \
    examples-rclcpp-minimal-timer \
    examples-rclcpp-multithreaded-executor \
    examples-rclpy-executors \
    examples-rclpy-minimal-action-client \
    examples-rclpy-minimal-action-server \
    examples-rclpy-minimal-client \
    examples-rclpy-minimal-publisher \
    examples-rclpy-minimal-service \
    examples-rclpy-minimal-subscriber \
    image-tools \
    intra-process-demo \
    joy \
    lifecycle \
    logging-demo \
    pcl-conversions \
    quality-of-service-demo-cpp \
    quality-of-service-demo-py \
    ros-base \
    teleop-twist-joy \
    teleop-twist-keyboard \
    tlsf \
    tlsf-cpp \
    topic-monitor \
    rclcpp-dev \
    std-msgs-dev \
    moveit-ros-planning \
    moveit-servo \
    moveit-ros-planning-interface \
    moveit-common \
    moveit-ros-robot-interaction \
    octomap \
    realsense2-camera \
    rclcpp \
    rclc \
    rcl-yaml-param-parser \
    gpsd-client \
    image-pipeline \
    depth-image-proc \
    image-common \
    image-transport \
    camera-calibration-parsers \
    imu-complementary-filter \
    imu-filter-madgwick \
    map-transformer \
    maliput \
    maliput-dragway \
    maliput-drake \
    maliput-object-py \
    maliput-malidrive \
    maliput-multilane \
    maliput-sparse \
    maliput-py \
    swri-prefix-tools \
    swri-roscpp \
    bosch-locator-bridge \
    marti-can-msgs \
    marti-common-msgs \
    marti-dbw-msgs \
    marti-nav-msgs \
    marti-perception-msgs \
    marti-sensor-msgs \
    marti-status-msgs \
    marti-visualization-msgs \
    libmavconn \
    cartographer-ros \
    fastrtps \
    mavros \
    mavros-msgs \
    move-base-msgs \
    navigation2 \
    octomap-server \
    octomap-mapping \
    odom-to-tf-ros2 \    
    raptor-dbw-msgs \
    raptor-pdu-msgs \
    raspimouse-msgs \
    rcdiscover \
    rc-genicam-api \
    rc-genicam-driver \
    rc-reason-msgs \
    ros2-control \
    ros2-controllers \
    rosapi \
    rosapi-msgs \
    rosbridge-library \
    rosbridge-server \
    rttest \
    sros2 \
    tlsf-cpp \
    v4l2-camera \
"

