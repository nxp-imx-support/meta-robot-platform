FILESEXTRAPATHS:prepend := "${THISDIR}/ai-robot:"

SRC_URI:append = " \
file://0001-Add-i.MX8M-Plus-AI-Robot-board.patch \
"
