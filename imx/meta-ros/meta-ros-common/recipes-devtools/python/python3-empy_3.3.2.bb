require python-empy.inc

inherit setuptools3

SRC_URI += "file://fix-invalid-command-bdist_wheel.patch \
"