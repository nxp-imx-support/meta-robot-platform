# Copyright 2019-2023 NXP

ROS_EXPORT_DEPENDS:remove = " \
    rviz-imu-plugin \
"

ROS_EXEC_DEPENDS:remove = " \
    rviz-imu-plugin \
"
