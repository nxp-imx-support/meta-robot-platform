DEPENDS += " python-qt-binding"

