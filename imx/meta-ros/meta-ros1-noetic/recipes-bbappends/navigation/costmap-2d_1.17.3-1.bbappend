# Copyright 2019-2023 NXP

# Missing license version in package.xml
LICENSE = "LGPL-2.1+"

# FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
# SRC_URI += "file://0001-Check-input-parameter-of-getCost-when-get-cost-from-.patch \
# "