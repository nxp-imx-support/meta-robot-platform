FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Fix-the-issue-which-libuvc_internal.h-14-10-fatal-er.patch"
