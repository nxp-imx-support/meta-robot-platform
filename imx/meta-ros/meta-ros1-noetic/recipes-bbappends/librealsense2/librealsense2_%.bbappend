# Copyright 2020-2023 NXP

inherit ros_insane_dev_so
