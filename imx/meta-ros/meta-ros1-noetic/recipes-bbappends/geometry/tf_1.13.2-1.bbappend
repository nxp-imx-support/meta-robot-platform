FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Fix-tf-broken-which-TypeError-string-pattern-on-a-by.patch"
