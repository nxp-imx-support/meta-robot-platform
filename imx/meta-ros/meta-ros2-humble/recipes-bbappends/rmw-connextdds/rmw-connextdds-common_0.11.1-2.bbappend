# Copyright 2019-2023 NXP

ROS_BUILD_DEPENDS += " \
    rosidl-generator-c \
    rosidl-generator-cpp \
"
