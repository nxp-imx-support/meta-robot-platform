# Copyright 2019-2023 NXP

ROS_BUILDTOOL_DEPENDS += " \
    python3-empy-native \
    rcutils-native \
    ${PYTHON_PN}-numpy-native \
"

