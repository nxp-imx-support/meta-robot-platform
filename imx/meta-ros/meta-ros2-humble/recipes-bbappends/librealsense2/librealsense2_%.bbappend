# Copyright 2019-2023 NXP

inherit ros_insane_dev_so

EXTRA_OECMAKE += " -DFORCE_LIBUVC=ON"
