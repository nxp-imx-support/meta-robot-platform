# Copyright 2019-2023 NXP

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    ${PYTHON_PN}-numpy-native \
"