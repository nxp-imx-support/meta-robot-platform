# Copyright 2019-2023 NXP

INSANE_SKIP:${PN} += "file-rdeps shebang-size"