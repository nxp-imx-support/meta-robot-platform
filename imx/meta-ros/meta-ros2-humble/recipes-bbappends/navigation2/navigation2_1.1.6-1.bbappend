# Copyright (c) 2020 LG Electronics, Inc.

# All rviz recipes aren't available without qtbase
ROS_EXEC_DEPENDS:remove = "nav2-rviz-plugins"
