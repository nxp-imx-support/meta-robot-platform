# Copyright 2019-2023 NXP

ROS_BUILDTOOL_DEPENDS += " \
    std-msgs \
    ${PYTHON_PN}-numpy-native \
"
