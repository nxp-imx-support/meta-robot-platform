# Every ROS recipe, generated or not, must contain "inherit ros_distro_${ROS_DISTRO}".
#
# Copyright 2019-2023 NXP

ROS_DISTRO = "humble"

inherit ${ROS_DISTRO_TYPE}_distro
