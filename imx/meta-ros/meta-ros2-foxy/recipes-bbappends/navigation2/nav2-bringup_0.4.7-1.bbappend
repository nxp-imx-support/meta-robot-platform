# Copyright 2019-2023 NXP

ROS_EXEC_DEPENDS:remove = " \
    slam-toolbox \
"
